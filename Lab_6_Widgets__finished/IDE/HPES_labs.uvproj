# Keil uVision project HPES_labs.uvproj, settings and files
target HPES_Lab (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HPES_labs
  c flags: Optim=1
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1 UART_BUFFERED
  c include: ..\app;..\stellarisware;..\hal
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group IDE
    ./: Startup.s Retarget.c File_Config.c
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
    ../hal/: SPI_LM3S37x8.c
    ../stellarisware/driverlib/: grlib-cm3.lib
  group hal
    ../hal/: hal_led.c hal_system.c cmdline.c cmdline.h hal_led.h hal_system.h uartstdio.h ustdlib.h uartstdio.c ustdlib.c touch.c kitronix320x240x16_ssd2119_8bit.c set_pinout.c
  group app
    ../app/: main.c RTX_Config.c main.h tlv320aic23b.c
    ../hal/: sound.c
  group stellarisware
    ../stellarisware/driverlib/: adc.c cpu.c flash.c gpio.c i2c.c i2s.c interrupt.c ssi.c sysctl.c timer.c uart.c udma.c epi.c
    ../stellarisware/grlib/: grlib.h widget.h
